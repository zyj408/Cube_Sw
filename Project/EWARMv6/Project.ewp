# IAR project Project.ewp, settings and files
configuration Flash (ARM, debug)
  General.OGChipSelectEditMenu: STM32F4xxx ST STM32F4xxx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F40XX
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\Libraries\CMSIS\Include; ..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\User\bsp_stm32f4xx; ..\..\User\bsp_stm32f4xx\inc; ..\..\User; ..\..\uCOS-III\uC-CPU; ..\..\uCOS-III\uC-CPU\ARM-Cortex-M4\IAR; ..\..\uCOS-III\uC-LIB; ..\..\uCOS-III\uC-LIB\Ports\ARM-Cortex-M4\IAR; ..\..\uCOS-III\uCOS-III\Source; ..\..\uCOS-III\uCOS-III\Ports\ARM-Cortex-M4\Generic\IAR; ..\..\User\fatfs\src; ..\..\User\fonts; ..\..\emWin\Config; ..\..\emWin\GUI_X; ..\..\emWin\Include; ..\..\emWin\emWinTask
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  postbuild: CopyHex_Flash.bat
  ILINK.IlinkOutputFile: stm32-f4.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration CpuRAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; VECT_TAB_SRAM; STM32F40_41xxx
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\Libraries\CMSIS\Include; ..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\User\bsp_stm32f4xx; ..\..\User\bsp_stm32f4xx\inc; ..\..\User
  ILINK.IlinkIcfFile: stm32f4xx_ram.icf
  group BSP
    ../../User/bsp_stm32f4xx/: bsp.c bsp_os.c stm32f4xx_it.c
    ../../User/bsp_stm32f4xx/src/: bsp_key.c bsp_led.c bsp_printf.c bsp_sdio_sd.c bsp_uart.c
  group CMSIS
    ../../User/bsp_stm32f4xx/: system_stm32f4xx.c
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.例程修改记录.txt 03.开发环境说明.txt 04.STM32F407IGT6引脚定义(原始定义).txt 05.GPIO分配表(按GPIO次序排列).txt 06.GPIO分配表(按功能排列).txt
  group EWARMv6
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f40_41xxx.s
  group FatFS
    ../../User/fatfs/src/: diskio.c diskio.h ff.c ff.h ffconf.h integer.h
  group fonts
    ../../User/fonts/: asc12.c asc16.c fonts.h hz12.c hz16.c hzk12s.c hzk16fs.c hzk16s.c hzk24h.c hzk24k.c hzk24s.c SimSun_1616.c SimSun_2424.c
  group GUI/Config
    ../../emWin/Config/: GUIConf.c GUIConf.h LCDConf.c LCDConf.h
  group GUI/DEMO
    ../../emWin/emWinTask/: App_DispPic.c MainTask.c MainTask.h
  group GUI/Lib
    ../../emWin/GUILib/: STemWin522_CM4_OS_IAR.a
  group GUI_X
    ../../emWin/GUI_X/: GUI_VNC_X.c GUI_X_Ex.c GUI_X_Touch_Analog.c GUI_X_Touch_StoreState.c
  group LCD_Driver
    ../../User/bsp_stm32f4xx/src/: bsp_tft_lcd.c bsp_touch.c LCD_RA8875.c LCD_SPFD5420.c
    ../../emWin/DisplayDriver/: GUIDRV_Template.c
  group StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c
  group uC/CPU
    ../../uCOS-III/uC-CPU/ARM-Cortex-M4/IAR/: cpu.h cpu_a.asm cpu_c.c
    ../../uCOS-III/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group uC/LIB
    ../../uCOS-III/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../../uCOS-III/uC-LIB/Ports/ARM-Cortex-M4/IAR/: lib_mem_a.asm
  group uC/OS-III Port
    ../../uCOS-III/uCOS-III/Ports/ARM-Cortex-M4/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group uC/OS-III Source
    ../../uCOS-III/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group User
    ../../User/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h main.c os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
